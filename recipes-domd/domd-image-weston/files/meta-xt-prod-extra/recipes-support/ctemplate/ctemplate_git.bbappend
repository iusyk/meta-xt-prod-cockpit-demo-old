SRC_URI = "git://github.com/svn2github/ctemplate.git;protocol=https"
