IMAGE_INSTALL_append_kingfisher = " \
    iw \
"

IMAGE_INSTALL_remove_kingfisher = " \
    wireless-tools \
"

